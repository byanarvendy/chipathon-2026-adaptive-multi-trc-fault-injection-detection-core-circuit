v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 1150 -2280 1150 -2200 {lab=12_out}
N 1150 -2280 1170 -2280 {lab=12_out}
N 420 -2180 450 -2180 {lab=12_in}
N 330 -2200 450 -2200 {lab=clk_in}
N 1290 -2300 1330 -2300 {lab=xor_out}
N 330 -2140 330 -2090 {lab=0}
N 1290 -2320 1330 -2320 {lab=clk_in}
N 630 -2180 630 -2130 {lab=12_in}
N 440 -2160 450 -2160 {lab=tiehi}
N 1510 -2300 1530 -2300 {lab=#net1}
N 1330 -2280 1330 -2250 {lab=tiehi}
N 110 -2170 110 -2140 {lab=VSS}
N 190 -2180 190 -2150 {lab=tiehi}
N 630 -2220 630 -2200 {lab=#net2}
N 420 -2180 420 -2130 {lab=12_in}
N 420 -2130 630 -2130 {lab=12_in}
N 630 -2180 650 -2180 {lab=12_in}
N 550 -5000 560 -5000 {lab=#net3}
N 460 -5000 470 -5000 {lab=12_in}
N 730 -5000 740 -5000 {lab=#net4}
N 640 -5000 650 -5000 {lab=#net5}
N 910 -5000 920 -5000 {lab=#net6}
N 820 -5000 830 -5000 {lab=#net7}
N 1090 -5000 1100 -5000 {lab=#net8}
N 1000 -5000 1010 -5000 {lab=#net9}
N 1270 -5000 1280 -5000 {lab=#net10}
N 1180 -5000 1190 -5000 {lab=#net11}
N 1450 -5000 1460 -5000 {lab=#net12}
N 1360 -5000 1370 -5000 {lab=#net13}
N 550 -4890 560 -4890 {lab=#net14}
N 460 -4890 470 -4890 {lab=24_in}
N 730 -4890 740 -4890 {lab=#net15}
N 640 -4890 650 -4890 {lab=#net16}
N 910 -4890 920 -4890 {lab=#net17}
N 820 -4890 830 -4890 {lab=#net18}
N 1090 -4890 1100 -4890 {lab=#net19}
N 1000 -4890 1010 -4890 {lab=#net20}
N 1270 -4890 1280 -4890 {lab=#net21}
N 1180 -4890 1190 -4890 {lab=#net22}
N 1450 -4890 1460 -4890 {lab=#net23}
N 1360 -4890 1370 -4890 {lab=#net24}
N 1440 -4820 1450 -4820 {lab=#net25}
N 1530 -4820 1540 -4820 {lab=#net26}
N 1260 -4820 1270 -4820 {lab=#net27}
N 1350 -4820 1360 -4820 {lab=#net28}
N 1080 -4820 1090 -4820 {lab=#net29}
N 1170 -4820 1180 -4820 {lab=#net30}
N 900 -4820 910 -4820 {lab=#net31}
N 990 -4820 1000 -4820 {lab=#net32}
N 720 -4820 730 -4820 {lab=#net33}
N 810 -4820 820 -4820 {lab=#net34}
N 540 -4820 550 -4820 {lab=#net35}
N 630 -4820 640 -4820 {lab=#net36}
N 550 -4710 560 -4710 {lab=#net37}
N 460 -4710 470 -4710 {lab=36_in}
N 730 -4710 740 -4710 {lab=#net38}
N 640 -4710 650 -4710 {lab=#net39}
N 910 -4710 920 -4710 {lab=#net40}
N 820 -4710 830 -4710 {lab=#net41}
N 1090 -4710 1100 -4710 {lab=#net42}
N 1000 -4710 1010 -4710 {lab=#net43}
N 1270 -4710 1280 -4710 {lab=#net44}
N 1180 -4710 1190 -4710 {lab=#net45}
N 1450 -4710 1460 -4710 {lab=#net46}
N 1360 -4710 1370 -4710 {lab=#net47}
N 1440 -4640 1450 -4640 {lab=#net48}
N 1530 -4640 1540 -4640 {lab=#net49}
N 1260 -4640 1270 -4640 {lab=#net50}
N 1350 -4640 1360 -4640 {lab=#net51}
N 1080 -4640 1090 -4640 {lab=#net52}
N 1170 -4640 1180 -4640 {lab=#net53}
N 900 -4640 910 -4640 {lab=#net54}
N 990 -4640 1000 -4640 {lab=#net55}
N 720 -4640 730 -4640 {lab=#net56}
N 810 -4640 820 -4640 {lab=#net57}
N 540 -4640 550 -4640 {lab=#net58}
N 630 -4640 640 -4640 {lab=#net59}
N 540 -4560 550 -4560 {lab=#net60}
N 720 -4560 730 -4560 {lab=#net61}
N 630 -4560 640 -4560 {lab=#net62}
N 900 -4560 910 -4560 {lab=#net63}
N 810 -4560 820 -4560 {lab=#net64}
N 1080 -4560 1090 -4560 {lab=#net65}
N 990 -4560 1000 -4560 {lab=#net66}
N 1260 -4560 1270 -4560 {lab=#net67}
N 1170 -4560 1180 -4560 {lab=#net68}
N 1440 -4560 1450 -4560 {lab=#net69}
N 1350 -4560 1360 -4560 {lab=#net70}
N 1540 -5000 1550 -5000 {lab=12_out}
N 1540 -4890 1540 -4820 {lab=#net26}
N 440 -4820 460 -4820 {lab=24_out}
N 1540 -4710 1540 -4640 {lab=#net49}
N 460 -4640 460 -4560 {lab=#net71}
N 1530 -4560 1540 -4560 {lab=36_out}
N 1970 -5040 1980 -5040 {lab=#net72}
N 1880 -5040 1890 -5040 {lab=48_in}
N 2150 -5040 2160 -5040 {lab=#net73}
N 2060 -5040 2070 -5040 {lab=#net74}
N 2330 -5040 2340 -5040 {lab=#net75}
N 2240 -5040 2250 -5040 {lab=#net76}
N 2510 -5040 2520 -5040 {lab=#net77}
N 2420 -5040 2430 -5040 {lab=#net78}
N 2690 -5040 2700 -5040 {lab=#net79}
N 2600 -5040 2610 -5040 {lab=#net80}
N 2870 -5040 2880 -5040 {lab=#net81}
N 2780 -5040 2790 -5040 {lab=#net82}
N 2860 -4970 2870 -4970 {lab=#net83}
N 2950 -4970 2960 -4970 {lab=#net84}
N 2680 -4970 2690 -4970 {lab=#net85}
N 2770 -4970 2780 -4970 {lab=#net86}
N 2500 -4970 2510 -4970 {lab=#net87}
N 2590 -4970 2600 -4970 {lab=#net88}
N 2320 -4970 2330 -4970 {lab=#net89}
N 2410 -4970 2420 -4970 {lab=#net90}
N 2140 -4970 2150 -4970 {lab=#net91}
N 2230 -4970 2240 -4970 {lab=#net92}
N 1960 -4970 1970 -4970 {lab=#net93}
N 2050 -4970 2060 -4970 {lab=#net94}
N 2960 -5040 2960 -4970 {lab=#net84}
N 1860 -4970 1880 -4970 {lab=#net95}
N 1970 -4890 1980 -4890 {lab=#net96}
N 2150 -4890 2160 -4890 {lab=#net97}
N 2060 -4890 2070 -4890 {lab=#net98}
N 2330 -4890 2340 -4890 {lab=#net99}
N 2240 -4890 2250 -4890 {lab=#net100}
N 2510 -4890 2520 -4890 {lab=#net101}
N 2420 -4890 2430 -4890 {lab=#net102}
N 2690 -4890 2700 -4890 {lab=#net103}
N 2600 -4890 2610 -4890 {lab=#net104}
N 2870 -4890 2880 -4890 {lab=#net105}
N 2780 -4890 2790 -4890 {lab=#net106}
N 2860 -4820 2870 -4820 {lab=#net107}
N 2950 -4820 2960 -4820 {lab=#net108}
N 2680 -4820 2690 -4820 {lab=#net109}
N 2770 -4820 2780 -4820 {lab=#net110}
N 2500 -4820 2510 -4820 {lab=#net111}
N 2590 -4820 2600 -4820 {lab=#net112}
N 2320 -4820 2330 -4820 {lab=#net113}
N 2410 -4820 2420 -4820 {lab=#net114}
N 2140 -4820 2150 -4820 {lab=#net115}
N 2230 -4820 2240 -4820 {lab=#net116}
N 1960 -4820 1970 -4820 {lab=#net117}
N 2050 -4820 2060 -4820 {lab=#net118}
N 2960 -4890 2960 -4820 {lab=#net108}
N 1860 -4820 1880 -4820 {lab=48_out}
N 1860 -4970 1860 -4890 {lab=#net95}
N 1860 -4890 1890 -4890 {lab=#net95}
N 1130 -1990 1130 -1910 {lab=24_out}
N 1130 -1990 1150 -1990 {lab=24_out}
N 400 -1890 430 -1890 {lab=24_in}
N 310 -1910 430 -1910 {lab=clk_in}
N 1270 -2010 1310 -2010 {lab=xor_out1}
N 1270 -2030 1310 -2030 {lab=clk_in}
N 1490 -2030 1540 -2030 {lab=vout1}
N 610 -1890 610 -1840 {lab=24_in}
N 420 -1870 430 -1870 {lab=tiehi}
N 1490 -2010 1510 -2010 {lab=#net119}
N 1310 -1990 1310 -1960 {lab=tiehi}
N 610 -1930 610 -1910 {lab=#net120}
N 400 -1890 400 -1840 {lab=24_in}
N 400 -1840 610 -1840 {lab=24_in}
N 610 -1890 630 -1890 {lab=24_in}
N 1110 -1680 1110 -1600 {lab=36_out}
N 1110 -1680 1130 -1680 {lab=36_out}
N 380 -1580 410 -1580 {lab=36_in}
N 290 -1600 410 -1600 {lab=clk_in}
N 1250 -1700 1290 -1700 {lab=xor_out2}
N 1250 -1720 1290 -1720 {lab=clk_in}
N 1470 -1720 1520 -1720 {lab=vout2}
N 590 -1580 590 -1530 {lab=36_in}
N 400 -1560 410 -1560 {lab=tiehi}
N 1470 -1700 1490 -1700 {lab=#net121}
N 1290 -1680 1290 -1650 {lab=tiehi}
N 590 -1620 590 -1600 {lab=#net122}
N 380 -1580 380 -1530 {lab=36_in}
N 380 -1530 590 -1530 {lab=36_in}
N 590 -1580 610 -1580 {lab=36_in}
N 1100 -1420 1100 -1340 {lab=48_out}
N 1100 -1420 1120 -1420 {lab=48_out}
N 370 -1320 400 -1320 {lab=48_in}
N 280 -1340 400 -1340 {lab=clk_in}
N 1240 -1440 1280 -1440 {lab=xor_out3}
N 1240 -1460 1280 -1460 {lab=clk_in}
N 1460 -1460 1510 -1460 {lab=vout3}
N 580 -1320 580 -1270 {lab=48_in}
N 390 -1300 400 -1300 {lab=tiehi}
N 1460 -1440 1480 -1440 {lab=#net123}
N 1280 -1420 1280 -1390 {lab=tiehi}
N 580 -1360 580 -1340 {lab=#net124}
N 370 -1320 370 -1270 {lab=48_in}
N 370 -1270 580 -1270 {lab=48_in}
N 580 -1320 600 -1320 {lab=48_in}
N 1510 -2320 1530 -2320 {lab=vout}
N 650 -2320 650 -2180 {lab=12_in}
N 650 -2320 1170 -2320 {lab=12_in}
N 630 -2030 1150 -2030 {lab=24_in}
N 630 -2030 630 -1890 {lab=24_in}
N 610 -1720 610 -1580 {lab=36_in}
N 610 -1720 1130 -1720 {lab=36_in}
N 600 -1460 1120 -1460 {lab=48_in}
N 600 -1460 600 -1320 {lab=48_in}
N 1950 -4640 1960 -4640 {lab=#net125}
N 1860 -4640 1870 -4640 {lab=96_in}
N 2130 -4640 2140 -4640 {lab=#net126}
N 2040 -4640 2050 -4640 {lab=#net127}
N 2310 -4640 2320 -4640 {lab=#net128}
N 2220 -4640 2230 -4640 {lab=#net129}
N 2490 -4640 2500 -4640 {lab=#net130}
N 2400 -4640 2410 -4640 {lab=#net131}
N 2670 -4640 2680 -4640 {lab=#net132}
N 2580 -4640 2590 -4640 {lab=#net133}
N 2850 -4640 2860 -4640 {lab=#net134}
N 2760 -4640 2770 -4640 {lab=#net135}
N 2840 -4570 2850 -4570 {lab=#net136}
N 2930 -4570 2940 -4570 {lab=#net137}
N 2660 -4570 2670 -4570 {lab=#net138}
N 2750 -4570 2760 -4570 {lab=#net139}
N 2480 -4570 2490 -4570 {lab=#net140}
N 2570 -4570 2580 -4570 {lab=#net141}
N 2300 -4570 2310 -4570 {lab=#net142}
N 2390 -4570 2400 -4570 {lab=#net143}
N 2120 -4570 2130 -4570 {lab=#net144}
N 2210 -4570 2220 -4570 {lab=#net145}
N 1940 -4570 1950 -4570 {lab=#net146}
N 2030 -4570 2040 -4570 {lab=#net147}
N 2940 -4640 2940 -4570 {lab=#net137}
N 1840 -4570 1860 -4570 {lab=#net148}
N 1950 -4490 1960 -4490 {lab=#net149}
N 2130 -4490 2140 -4490 {lab=#net150}
N 2040 -4490 2050 -4490 {lab=#net151}
N 2310 -4490 2320 -4490 {lab=#net152}
N 2220 -4490 2230 -4490 {lab=#net153}
N 2490 -4490 2500 -4490 {lab=#net154}
N 2400 -4490 2410 -4490 {lab=#net155}
N 2670 -4490 2680 -4490 {lab=#net156}
N 2580 -4490 2590 -4490 {lab=#net157}
N 2850 -4490 2860 -4490 {lab=#net158}
N 2760 -4490 2770 -4490 {lab=#net159}
N 2840 -4420 2850 -4420 {lab=#net160}
N 2930 -4420 2940 -4420 {lab=#net161}
N 2660 -4420 2670 -4420 {lab=#net162}
N 2750 -4420 2760 -4420 {lab=#net163}
N 2480 -4420 2490 -4420 {lab=#net164}
N 2570 -4420 2580 -4420 {lab=#net165}
N 2300 -4420 2310 -4420 {lab=#net166}
N 2390 -4420 2400 -4420 {lab=#net167}
N 2120 -4420 2130 -4420 {lab=#net168}
N 2210 -4420 2220 -4420 {lab=#net169}
N 1940 -4420 1950 -4420 {lab=#net170}
N 2030 -4420 2040 -4420 {lab=#net171}
N 2940 -4490 2940 -4420 {lab=#net161}
N 1840 -4420 1860 -4420 {lab=#net172}
N 1840 -4570 1840 -4490 {lab=#net148}
N 1840 -4490 1870 -4490 {lab=#net148}
N 1960 -4300 1970 -4300 {lab=#net173}
N 2140 -4300 2150 -4300 {lab=#net174}
N 2050 -4300 2060 -4300 {lab=#net175}
N 2320 -4300 2330 -4300 {lab=#net176}
N 2230 -4300 2240 -4300 {lab=#net177}
N 2500 -4300 2510 -4300 {lab=#net178}
N 2410 -4300 2420 -4300 {lab=#net179}
N 2680 -4300 2690 -4300 {lab=#net180}
N 2590 -4300 2600 -4300 {lab=#net181}
N 2860 -4300 2870 -4300 {lab=#net182}
N 2770 -4300 2780 -4300 {lab=#net183}
N 2850 -4230 2860 -4230 {lab=#net184}
N 2940 -4230 2950 -4230 {lab=#net185}
N 2670 -4230 2680 -4230 {lab=#net186}
N 2760 -4230 2770 -4230 {lab=#net187}
N 2490 -4230 2500 -4230 {lab=#net188}
N 2580 -4230 2590 -4230 {lab=#net189}
N 2310 -4230 2320 -4230 {lab=#net190}
N 2400 -4230 2410 -4230 {lab=#net191}
N 2130 -4230 2140 -4230 {lab=#net192}
N 2220 -4230 2230 -4230 {lab=#net193}
N 1950 -4230 1960 -4230 {lab=#net194}
N 2040 -4230 2050 -4230 {lab=#net195}
N 2950 -4300 2950 -4230 {lab=#net185}
N 1850 -4230 1870 -4230 {lab=#net196}
N 1960 -4150 1970 -4150 {lab=#net197}
N 2140 -4150 2150 -4150 {lab=#net198}
N 2050 -4150 2060 -4150 {lab=#net199}
N 2320 -4150 2330 -4150 {lab=#net200}
N 2230 -4150 2240 -4150 {lab=#net201}
N 2500 -4150 2510 -4150 {lab=#net202}
N 2410 -4150 2420 -4150 {lab=#net203}
N 2680 -4150 2690 -4150 {lab=#net204}
N 2590 -4150 2600 -4150 {lab=#net205}
N 2860 -4150 2870 -4150 {lab=#net206}
N 2770 -4150 2780 -4150 {lab=#net207}
N 2850 -4080 2860 -4080 {lab=#net208}
N 2940 -4080 2950 -4080 {lab=#net209}
N 2670 -4080 2680 -4080 {lab=#net210}
N 2760 -4080 2770 -4080 {lab=#net211}
N 2490 -4080 2500 -4080 {lab=#net212}
N 2580 -4080 2590 -4080 {lab=#net213}
N 2310 -4080 2320 -4080 {lab=#net214}
N 2400 -4080 2410 -4080 {lab=#net215}
N 2130 -4080 2140 -4080 {lab=#net216}
N 2220 -4080 2230 -4080 {lab=#net217}
N 1950 -4080 1960 -4080 {lab=#net218}
N 2040 -4080 2050 -4080 {lab=#net219}
N 2950 -4150 2950 -4080 {lab=#net209}
N 1850 -4080 1870 -4080 {lab=96_out}
N 1850 -4230 1850 -4150 {lab=#net196}
N 1850 -4150 1880 -4150 {lab=#net196}
N 1840 -4420 1840 -4300 {lab=#net172}
N 1840 -4300 1880 -4300 {lab=#net172}
N 1100 -1110 1100 -1030 {lab=96_out}
N 1100 -1110 1120 -1110 {lab=96_out}
N 370 -1010 400 -1010 {lab=96_in}
N 280 -1030 400 -1030 {lab=clk_in}
N 1240 -1130 1280 -1130 {lab=xor_out4}
N 1240 -1150 1280 -1150 {lab=clk_in}
N 1460 -1150 1510 -1150 {lab=vout4}
N 580 -1010 580 -960 {lab=96_in}
N 390 -990 400 -990 {lab=tiehi}
N 1460 -1130 1480 -1130 {lab=#net220}
N 1280 -1110 1280 -1080 {lab=tiehi}
N 580 -1050 580 -1030 {lab=#net221}
N 370 -1010 370 -960 {lab=96_in}
N 370 -960 580 -960 {lab=96_in}
N 580 -1010 600 -1010 {lab=96_in}
N 600 -1150 1120 -1150 {lab=96_in}
N 600 -1150 600 -1010 {lab=96_in}
N 1100 -790 1100 -710 {lab=144_out}
N 1100 -790 1120 -790 {lab=144_out}
N 370 -690 400 -690 {lab=144_in}
N 280 -710 400 -710 {lab=clk_in}
N 1240 -810 1280 -810 {lab=xor_out5}
N 1240 -830 1280 -830 {lab=clk_in}
N 1460 -830 1510 -830 {lab=vout5}
N 580 -690 580 -640 {lab=144_in}
N 390 -670 400 -670 {lab=tiehi}
N 1460 -810 1480 -810 {lab=#net222}
N 1280 -790 1280 -760 {lab=tiehi}
N 580 -730 580 -710 {lab=#net223}
N 370 -690 370 -640 {lab=144_in}
N 370 -640 580 -640 {lab=144_in}
N 580 -690 600 -690 {lab=144_in}
N 600 -830 1120 -830 {lab=144_in}
N 600 -830 600 -690 {lab=144_in}
N 3420 -5070 3430 -5070 {lab=#net224}
N 3330 -5070 3340 -5070 {lab=192_in}
N 3600 -5070 3610 -5070 {lab=#net225}
N 3510 -5070 3520 -5070 {lab=#net226}
N 3780 -5070 3790 -5070 {lab=#net227}
N 3690 -5070 3700 -5070 {lab=#net228}
N 3960 -5070 3970 -5070 {lab=#net229}
N 3870 -5070 3880 -5070 {lab=#net230}
N 4140 -5070 4150 -5070 {lab=#net231}
N 4050 -5070 4060 -5070 {lab=#net232}
N 4320 -5070 4330 -5070 {lab=#net233}
N 4230 -5070 4240 -5070 {lab=#net234}
N 4310 -5000 4320 -5000 {lab=#net235}
N 4400 -5000 4410 -5000 {lab=#net236}
N 4130 -5000 4140 -5000 {lab=#net237}
N 4220 -5000 4230 -5000 {lab=#net238}
N 3950 -5000 3960 -5000 {lab=#net239}
N 4040 -5000 4050 -5000 {lab=#net240}
N 3770 -5000 3780 -5000 {lab=#net241}
N 3860 -5000 3870 -5000 {lab=#net242}
N 3590 -5000 3600 -5000 {lab=#net243}
N 3680 -5000 3690 -5000 {lab=#net244}
N 3410 -5000 3420 -5000 {lab=#net245}
N 3500 -5000 3510 -5000 {lab=#net246}
N 4410 -5070 4410 -5000 {lab=#net236}
N 3310 -5000 3330 -5000 {lab=#net247}
N 3420 -4920 3430 -4920 {lab=#net248}
N 3600 -4920 3610 -4920 {lab=#net249}
N 3510 -4920 3520 -4920 {lab=#net250}
N 3780 -4920 3790 -4920 {lab=#net251}
N 3690 -4920 3700 -4920 {lab=#net252}
N 3960 -4920 3970 -4920 {lab=#net253}
N 3870 -4920 3880 -4920 {lab=#net254}
N 4140 -4920 4150 -4920 {lab=#net255}
N 4050 -4920 4060 -4920 {lab=#net256}
N 4320 -4920 4330 -4920 {lab=#net257}
N 4230 -4920 4240 -4920 {lab=#net258}
N 4310 -4850 4320 -4850 {lab=#net259}
N 4400 -4850 4410 -4850 {lab=#net260}
N 4130 -4850 4140 -4850 {lab=#net261}
N 4220 -4850 4230 -4850 {lab=#net262}
N 3950 -4850 3960 -4850 {lab=#net263}
N 4040 -4850 4050 -4850 {lab=#net264}
N 3770 -4850 3780 -4850 {lab=#net265}
N 3860 -4850 3870 -4850 {lab=#net266}
N 3590 -4850 3600 -4850 {lab=#net267}
N 3680 -4850 3690 -4850 {lab=#net268}
N 3410 -4850 3420 -4850 {lab=#net269}
N 3500 -4850 3510 -4850 {lab=#net270}
N 4410 -4920 4410 -4850 {lab=#net260}
N 3310 -4850 3330 -4850 {lab=#net271}
N 3310 -5000 3310 -4920 {lab=#net247}
N 3310 -4920 3340 -4920 {lab=#net247}
N 3430 -4730 3440 -4730 {lab=#net272}
N 3610 -4730 3620 -4730 {lab=#net273}
N 3520 -4730 3530 -4730 {lab=#net274}
N 3790 -4730 3800 -4730 {lab=#net275}
N 3700 -4730 3710 -4730 {lab=#net276}
N 3970 -4730 3980 -4730 {lab=#net277}
N 3880 -4730 3890 -4730 {lab=#net278}
N 4150 -4730 4160 -4730 {lab=#net279}
N 4060 -4730 4070 -4730 {lab=#net280}
N 4330 -4730 4340 -4730 {lab=#net281}
N 4240 -4730 4250 -4730 {lab=#net282}
N 4320 -4660 4330 -4660 {lab=#net283}
N 4410 -4660 4420 -4660 {lab=#net284}
N 4140 -4660 4150 -4660 {lab=#net285}
N 4230 -4660 4240 -4660 {lab=#net286}
N 3960 -4660 3970 -4660 {lab=#net287}
N 4050 -4660 4060 -4660 {lab=#net288}
N 3780 -4660 3790 -4660 {lab=#net289}
N 3870 -4660 3880 -4660 {lab=#net290}
N 3600 -4660 3610 -4660 {lab=#net291}
N 3690 -4660 3700 -4660 {lab=#net292}
N 3420 -4660 3430 -4660 {lab=#net293}
N 3510 -4660 3520 -4660 {lab=#net294}
N 4420 -4730 4420 -4660 {lab=#net284}
N 3320 -4660 3340 -4660 {lab=#net295}
N 3430 -4580 3440 -4580 {lab=#net296}
N 3610 -4580 3620 -4580 {lab=#net297}
N 3520 -4580 3530 -4580 {lab=#net298}
N 3790 -4580 3800 -4580 {lab=#net299}
N 3700 -4580 3710 -4580 {lab=#net300}
N 3970 -4580 3980 -4580 {lab=#net301}
N 3880 -4580 3890 -4580 {lab=#net302}
N 4150 -4580 4160 -4580 {lab=#net303}
N 4060 -4580 4070 -4580 {lab=#net304}
N 4330 -4580 4340 -4580 {lab=#net305}
N 4240 -4580 4250 -4580 {lab=#net306}
N 4320 -4510 4330 -4510 {lab=#net307}
N 4410 -4510 4420 -4510 {lab=#net308}
N 4140 -4510 4150 -4510 {lab=#net309}
N 4230 -4510 4240 -4510 {lab=#net310}
N 3960 -4510 3970 -4510 {lab=#net311}
N 4050 -4510 4060 -4510 {lab=#net312}
N 3780 -4510 3790 -4510 {lab=#net313}
N 3870 -4510 3880 -4510 {lab=#net314}
N 3600 -4510 3610 -4510 {lab=#net315}
N 3690 -4510 3700 -4510 {lab=#net316}
N 3420 -4510 3430 -4510 {lab=#net317}
N 3510 -4510 3520 -4510 {lab=#net318}
N 4420 -4580 4420 -4510 {lab=#net308}
N 3320 -4510 3340 -4510 {lab=#net319}
N 3320 -4660 3320 -4580 {lab=#net295}
N 3320 -4580 3350 -4580 {lab=#net295}
N 3310 -4850 3310 -4730 {lab=#net271}
N 3310 -4730 3350 -4730 {lab=#net271}
N 3430 -4380 3440 -4380 {lab=#net320}
N 3610 -4380 3620 -4380 {lab=#net321}
N 3520 -4380 3530 -4380 {lab=#net322}
N 3790 -4380 3800 -4380 {lab=#net323}
N 3700 -4380 3710 -4380 {lab=#net324}
N 3970 -4380 3980 -4380 {lab=#net325}
N 3880 -4380 3890 -4380 {lab=#net326}
N 4150 -4380 4160 -4380 {lab=#net327}
N 4060 -4380 4070 -4380 {lab=#net328}
N 4330 -4380 4340 -4380 {lab=#net329}
N 4240 -4380 4250 -4380 {lab=#net330}
N 4320 -4310 4330 -4310 {lab=#net331}
N 4410 -4310 4420 -4310 {lab=#net332}
N 4140 -4310 4150 -4310 {lab=#net333}
N 4230 -4310 4240 -4310 {lab=#net334}
N 3960 -4310 3970 -4310 {lab=#net335}
N 4050 -4310 4060 -4310 {lab=#net336}
N 3780 -4310 3790 -4310 {lab=#net337}
N 3870 -4310 3880 -4310 {lab=#net338}
N 3600 -4310 3610 -4310 {lab=#net339}
N 3690 -4310 3700 -4310 {lab=#net340}
N 3420 -4310 3430 -4310 {lab=#net341}
N 3510 -4310 3520 -4310 {lab=#net342}
N 4420 -4380 4420 -4310 {lab=#net332}
N 3320 -4310 3340 -4310 {lab=#net343}
N 3430 -4230 3440 -4230 {lab=#net344}
N 3610 -4230 3620 -4230 {lab=#net345}
N 3520 -4230 3530 -4230 {lab=#net346}
N 3790 -4230 3800 -4230 {lab=#net347}
N 3700 -4230 3710 -4230 {lab=#net348}
N 3970 -4230 3980 -4230 {lab=#net349}
N 3880 -4230 3890 -4230 {lab=#net350}
N 4150 -4230 4160 -4230 {lab=#net351}
N 4060 -4230 4070 -4230 {lab=#net352}
N 4330 -4230 4340 -4230 {lab=#net353}
N 4240 -4230 4250 -4230 {lab=#net354}
N 4320 -4160 4330 -4160 {lab=#net355}
N 4410 -4160 4420 -4160 {lab=#net356}
N 4140 -4160 4150 -4160 {lab=#net357}
N 4230 -4160 4240 -4160 {lab=#net358}
N 3960 -4160 3970 -4160 {lab=#net359}
N 4050 -4160 4060 -4160 {lab=#net360}
N 3780 -4160 3790 -4160 {lab=#net361}
N 3870 -4160 3880 -4160 {lab=#net362}
N 3600 -4160 3610 -4160 {lab=#net363}
N 3690 -4160 3700 -4160 {lab=#net364}
N 3420 -4160 3430 -4160 {lab=#net365}
N 3510 -4160 3520 -4160 {lab=#net366}
N 4420 -4230 4420 -4160 {lab=#net356}
N 3320 -4160 3340 -4160 {lab=#net367}
N 3320 -4310 3320 -4230 {lab=#net343}
N 3320 -4230 3350 -4230 {lab=#net343}
N 3440 -4040 3450 -4040 {lab=#net368}
N 3620 -4040 3630 -4040 {lab=#net369}
N 3530 -4040 3540 -4040 {lab=#net370}
N 3800 -4040 3810 -4040 {lab=#net371}
N 3710 -4040 3720 -4040 {lab=#net372}
N 3980 -4040 3990 -4040 {lab=#net373}
N 3890 -4040 3900 -4040 {lab=#net374}
N 4160 -4040 4170 -4040 {lab=#net375}
N 4070 -4040 4080 -4040 {lab=#net376}
N 4340 -4040 4350 -4040 {lab=#net377}
N 4250 -4040 4260 -4040 {lab=#net378}
N 4330 -3970 4340 -3970 {lab=#net379}
N 4420 -3970 4430 -3970 {lab=#net380}
N 4150 -3970 4160 -3970 {lab=#net381}
N 4240 -3970 4250 -3970 {lab=#net382}
N 3970 -3970 3980 -3970 {lab=#net383}
N 4060 -3970 4070 -3970 {lab=#net384}
N 3790 -3970 3800 -3970 {lab=#net385}
N 3880 -3970 3890 -3970 {lab=#net386}
N 3610 -3970 3620 -3970 {lab=#net387}
N 3700 -3970 3710 -3970 {lab=#net388}
N 3430 -3970 3440 -3970 {lab=#net389}
N 3520 -3970 3530 -3970 {lab=#net390}
N 4430 -4040 4430 -3970 {lab=#net380}
N 3330 -3970 3350 -3970 {lab=#net391}
N 3440 -3890 3450 -3890 {lab=#net392}
N 3620 -3890 3630 -3890 {lab=#net393}
N 3530 -3890 3540 -3890 {lab=#net394}
N 3800 -3890 3810 -3890 {lab=#net395}
N 3710 -3890 3720 -3890 {lab=#net396}
N 3980 -3890 3990 -3890 {lab=#net397}
N 3890 -3890 3900 -3890 {lab=#net398}
N 4160 -3890 4170 -3890 {lab=#net399}
N 4070 -3890 4080 -3890 {lab=#net400}
N 4340 -3890 4350 -3890 {lab=#net401}
N 4250 -3890 4260 -3890 {lab=#net402}
N 4330 -3820 4340 -3820 {lab=#net403}
N 4420 -3820 4430 -3820 {lab=#net404}
N 4150 -3820 4160 -3820 {lab=#net405}
N 4240 -3820 4250 -3820 {lab=#net406}
N 3970 -3820 3980 -3820 {lab=#net407}
N 4060 -3820 4070 -3820 {lab=#net408}
N 3790 -3820 3800 -3820 {lab=#net409}
N 3880 -3820 3890 -3820 {lab=#net410}
N 3610 -3820 3620 -3820 {lab=#net411}
N 3700 -3820 3710 -3820 {lab=#net412}
N 3430 -3820 3440 -3820 {lab=#net413}
N 3520 -3820 3530 -3820 {lab=#net414}
N 4430 -3890 4430 -3820 {lab=#net404}
N 3330 -3820 3350 -3820 {lab=192_out}
N 3330 -3970 3330 -3890 {lab=#net391}
N 3330 -3890 3360 -3890 {lab=#net391}
N 3320 -4160 3320 -4040 {lab=#net367}
N 3320 -4040 3360 -4040 {lab=#net367}
N 3320 -4510 3320 -4380 {lab=#net319}
N 3320 -4380 3350 -4380 {lab=#net319}
N 1110 -510 1110 -430 {lab=192_out}
N 1110 -510 1130 -510 {lab=192_out}
N 380 -410 410 -410 {lab=192_in}
N 290 -430 410 -430 {lab=clk_in}
N 1250 -530 1290 -530 {lab=xor_out6}
N 1250 -550 1290 -550 {lab=clk_in}
N 1470 -550 1520 -550 {lab=vout6}
N 590 -410 590 -360 {lab=192_in}
N 400 -390 410 -390 {lab=tiehi}
N 1470 -530 1490 -530 {lab=#net415}
N 1290 -510 1290 -480 {lab=tiehi}
N 590 -450 590 -430 {lab=#net416}
N 380 -410 380 -360 {lab=192_in}
N 380 -360 590 -360 {lab=192_in}
N 590 -410 610 -410 {lab=192_in}
N 610 -550 1130 -550 {lab=192_in}
N 610 -550 610 -410 {lab=192_in}
N 1950 -3920 1960 -3920 {lab=#net417}
N 1860 -3920 1870 -3920 {lab=144_in}
N 2130 -3920 2140 -3920 {lab=#net418}
N 2040 -3920 2050 -3920 {lab=#net419}
N 2310 -3920 2320 -3920 {lab=#net420}
N 2220 -3920 2230 -3920 {lab=#net421}
N 2490 -3920 2500 -3920 {lab=#net422}
N 2400 -3920 2410 -3920 {lab=#net423}
N 2670 -3920 2680 -3920 {lab=#net424}
N 2580 -3920 2590 -3920 {lab=#net425}
N 2850 -3920 2860 -3920 {lab=#net426}
N 2760 -3920 2770 -3920 {lab=#net427}
N 2840 -3850 2850 -3850 {lab=#net428}
N 2930 -3850 2940 -3850 {lab=#net429}
N 2660 -3850 2670 -3850 {lab=#net430}
N 2750 -3850 2760 -3850 {lab=#net431}
N 2480 -3850 2490 -3850 {lab=#net432}
N 2570 -3850 2580 -3850 {lab=#net433}
N 2300 -3850 2310 -3850 {lab=#net434}
N 2390 -3850 2400 -3850 {lab=#net435}
N 2120 -3850 2130 -3850 {lab=#net436}
N 2210 -3850 2220 -3850 {lab=#net437}
N 1940 -3850 1950 -3850 {lab=#net438}
N 2030 -3850 2040 -3850 {lab=#net439}
N 2940 -3920 2940 -3850 {lab=#net429}
N 1840 -3850 1860 -3850 {lab=#net440}
N 1950 -3770 1960 -3770 {lab=#net441}
N 2130 -3770 2140 -3770 {lab=#net442}
N 2040 -3770 2050 -3770 {lab=#net443}
N 2310 -3770 2320 -3770 {lab=#net444}
N 2220 -3770 2230 -3770 {lab=#net445}
N 2490 -3770 2500 -3770 {lab=#net446}
N 2400 -3770 2410 -3770 {lab=#net447}
N 2670 -3770 2680 -3770 {lab=#net448}
N 2580 -3770 2590 -3770 {lab=#net449}
N 2850 -3770 2860 -3770 {lab=#net450}
N 2760 -3770 2770 -3770 {lab=#net451}
N 2840 -3700 2850 -3700 {lab=#net452}
N 2930 -3700 2940 -3700 {lab=#net453}
N 2660 -3700 2670 -3700 {lab=#net454}
N 2750 -3700 2760 -3700 {lab=#net455}
N 2480 -3700 2490 -3700 {lab=#net456}
N 2570 -3700 2580 -3700 {lab=#net457}
N 2300 -3700 2310 -3700 {lab=#net458}
N 2390 -3700 2400 -3700 {lab=#net459}
N 2120 -3700 2130 -3700 {lab=#net460}
N 2210 -3700 2220 -3700 {lab=#net461}
N 1940 -3700 1950 -3700 {lab=#net462}
N 2030 -3700 2040 -3700 {lab=#net463}
N 2940 -3770 2940 -3700 {lab=#net453}
N 1840 -3700 1860 -3700 {lab=#net464}
N 1840 -3850 1840 -3770 {lab=#net440}
N 1840 -3770 1870 -3770 {lab=#net440}
N 1960 -3580 1970 -3580 {lab=#net465}
N 2140 -3580 2150 -3580 {lab=#net466}
N 2050 -3580 2060 -3580 {lab=#net467}
N 2320 -3580 2330 -3580 {lab=#net468}
N 2230 -3580 2240 -3580 {lab=#net469}
N 2500 -3580 2510 -3580 {lab=#net470}
N 2410 -3580 2420 -3580 {lab=#net471}
N 2680 -3580 2690 -3580 {lab=#net472}
N 2590 -3580 2600 -3580 {lab=#net473}
N 2860 -3580 2870 -3580 {lab=#net474}
N 2770 -3580 2780 -3580 {lab=#net475}
N 2850 -3510 2860 -3510 {lab=#net476}
N 2940 -3510 2950 -3510 {lab=#net477}
N 2670 -3510 2680 -3510 {lab=#net478}
N 2760 -3510 2770 -3510 {lab=#net479}
N 2490 -3510 2500 -3510 {lab=#net480}
N 2580 -3510 2590 -3510 {lab=#net481}
N 2310 -3510 2320 -3510 {lab=#net482}
N 2400 -3510 2410 -3510 {lab=#net483}
N 2130 -3510 2140 -3510 {lab=#net484}
N 2220 -3510 2230 -3510 {lab=#net485}
N 1950 -3510 1960 -3510 {lab=#net486}
N 2040 -3510 2050 -3510 {lab=#net487}
N 2950 -3580 2950 -3510 {lab=#net477}
N 1850 -3510 1870 -3510 {lab=#net488}
N 1960 -3430 1970 -3430 {lab=#net489}
N 2140 -3430 2150 -3430 {lab=#net490}
N 2050 -3430 2060 -3430 {lab=#net491}
N 2320 -3430 2330 -3430 {lab=#net492}
N 2230 -3430 2240 -3430 {lab=#net493}
N 2500 -3430 2510 -3430 {lab=#net494}
N 2410 -3430 2420 -3430 {lab=#net495}
N 2680 -3430 2690 -3430 {lab=#net496}
N 2590 -3430 2600 -3430 {lab=#net497}
N 2860 -3430 2870 -3430 {lab=#net498}
N 2770 -3430 2780 -3430 {lab=#net499}
N 2850 -3360 2860 -3360 {lab=#net500}
N 2940 -3360 2950 -3360 {lab=#net501}
N 2670 -3360 2680 -3360 {lab=#net502}
N 2760 -3360 2770 -3360 {lab=#net503}
N 2490 -3360 2500 -3360 {lab=#net504}
N 2580 -3360 2590 -3360 {lab=#net505}
N 2310 -3360 2320 -3360 {lab=#net506}
N 2400 -3360 2410 -3360 {lab=#net507}
N 2130 -3360 2140 -3360 {lab=#net508}
N 2220 -3360 2230 -3360 {lab=#net509}
N 1950 -3360 1960 -3360 {lab=#net510}
N 2040 -3360 2050 -3360 {lab=#net511}
N 2950 -3430 2950 -3360 {lab=#net501}
N 1850 -3360 1870 -3360 {lab=#net512}
N 1850 -3510 1850 -3430 {lab=#net488}
N 1850 -3430 1880 -3430 {lab=#net488}
N 1840 -3700 1840 -3580 {lab=#net464}
N 1840 -3580 1880 -3580 {lab=#net464}
N 1960 -3250 1970 -3250 {lab=#net513}
N 2140 -3250 2150 -3250 {lab=#net514}
N 2050 -3250 2060 -3250 {lab=#net515}
N 2320 -3250 2330 -3250 {lab=#net516}
N 2230 -3250 2240 -3250 {lab=#net517}
N 2500 -3250 2510 -3250 {lab=#net518}
N 2410 -3250 2420 -3250 {lab=#net519}
N 2680 -3250 2690 -3250 {lab=#net520}
N 2590 -3250 2600 -3250 {lab=#net521}
N 2860 -3250 2870 -3250 {lab=#net522}
N 2770 -3250 2780 -3250 {lab=#net523}
N 2850 -3180 2860 -3180 {lab=#net524}
N 2940 -3180 2950 -3180 {lab=#net525}
N 2670 -3180 2680 -3180 {lab=#net526}
N 2760 -3180 2770 -3180 {lab=#net527}
N 2490 -3180 2500 -3180 {lab=#net528}
N 2580 -3180 2590 -3180 {lab=#net529}
N 2310 -3180 2320 -3180 {lab=#net530}
N 2400 -3180 2410 -3180 {lab=#net531}
N 2130 -3180 2140 -3180 {lab=#net532}
N 2220 -3180 2230 -3180 {lab=#net533}
N 1950 -3180 1960 -3180 {lab=#net534}
N 2040 -3180 2050 -3180 {lab=#net535}
N 2950 -3250 2950 -3180 {lab=#net525}
N 1850 -3180 1870 -3180 {lab=#net536}
N 1960 -3100 1970 -3100 {lab=#net537}
N 2140 -3100 2150 -3100 {lab=#net538}
N 2050 -3100 2060 -3100 {lab=#net539}
N 2320 -3100 2330 -3100 {lab=#net540}
N 2230 -3100 2240 -3100 {lab=#net541}
N 2500 -3100 2510 -3100 {lab=#net542}
N 2410 -3100 2420 -3100 {lab=#net543}
N 2680 -3100 2690 -3100 {lab=#net544}
N 2590 -3100 2600 -3100 {lab=#net545}
N 2860 -3100 2870 -3100 {lab=#net546}
N 2770 -3100 2780 -3100 {lab=#net547}
N 2850 -3030 2860 -3030 {lab=#net548}
N 2940 -3030 2950 -3030 {lab=#net549}
N 2670 -3030 2680 -3030 {lab=#net550}
N 2760 -3030 2770 -3030 {lab=#net551}
N 2490 -3030 2500 -3030 {lab=#net552}
N 2580 -3030 2590 -3030 {lab=#net553}
N 2310 -3030 2320 -3030 {lab=#net554}
N 2400 -3030 2410 -3030 {lab=#net555}
N 2130 -3030 2140 -3030 {lab=#net556}
N 2220 -3030 2230 -3030 {lab=#net557}
N 1950 -3030 1960 -3030 {lab=#net558}
N 2040 -3030 2050 -3030 {lab=#net559}
N 2950 -3100 2950 -3030 {lab=#net549}
N 1850 -3030 1870 -3030 {lab=144_out}
N 1850 -3180 1850 -3100 {lab=#net536}
N 1850 -3100 1880 -3100 {lab=#net536}
N 1850 -3360 1850 -3250 {lab=#net512}
N 1850 -3250 1880 -3250 {lab=#net512}
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 540 -2180 0 0 {name=x5 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_xor2_1.sym} 1230 -2300 0 0 {name=x6 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 1420 -2300 0 0 {name=x8 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {vsource.sym} 330 -2170 0 0 {name=V1 value="PULSE(0 1.8 0 100p 100p 5n 10n)" savecurrent=false}
C {lab_pin.sym} 390 -2200 0 0 {name=p1 sig_type=std_logic lab=clk_in
}
C {lab_pin.sym} 1290 -2320 0 0 {name=p2 sig_type=std_logic lab=clk_in
}
C {gnd.sym} 330 -2090 0 0 {name=l1 lab=0}
C {noconn.sym} 1530 -2300 2 0 {name=l4}
C {code_shown.sym} -860 -1440 0 0 {name=s1 only_toplevel=false value=".include "/foss/pdks/ihp-sg13g2/libs.ref/sg13g2_stdcell/spice/sg13g2_stdcell.spice"

.control
set filetype=binary
tran 10p 100n
write untitled.raw all
quit
.endc"}
C {gnd.sym} 110 -2080 0 0 {name=l6 lab=0}
C {vsource.sym} 110 -2110 0 0 {name=V3 value=0 savecurrent=false}
C {lab_pin.sym} 110 -2170 0 0 {name=p5 sig_type=std_logic lab=VSS}
C {simulator_commands_shown.sym} -1270 -1360 0 0 {
name=Libs_Ngspice
simulator=ngspice
only_toplevel=false
value="
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerDIO.lib dio_tt
"
      }
C {simulator_commands_shown.sym} -1250 -1150 0 0 {
name=Libs_Xyce
simulator=xyce
only_toplevel=false
value="tcleval(
.lib $::SG13G2_MODELS_XYCE/cornerMOSlv.lib mos_tt
.lib $::SG13G2_MODELS_XYCE/cornerMOShv.lib mos_tt
.lib $::SG13G2_MODELS_XYCE/cornerHBT.lib hbt_typ
.lib $::SG13G2_MODELS_XYCE/cornerRES.lib res_typ
.lib $::SG13G2_MODELS_XYCE/cornerDIO.lib dio_typ
)"
      }
C {code_shown.sym} -1540 -1220 0 0 {name=s2 only_toplevel=false value="VDDSRC VDD 0 PWL(0 1.8 5n 1.8 5.0000001n 0.7 25n 0.7 25.0001n 1.8)"}
C {lab_wire.sym} 1330 -2250 0 0 {name=p19 sig_type=std_logic lab=tiehi
}
C {lab_wire.sym} 440 -2160 0 0 {name=p20 sig_type=std_logic lab=tiehi
}
C {gnd.sym} 190 -2090 0 0 {name=l2 lab=0}
C {vsource.sym} 190 -2120 0 0 {name=V2 value=1.8 savecurrent=false}
C {lab_pin.sym} 190 -2180 0 0 {name=p27 sig_type=std_logic lab=tiehi
}
C {noconn.sym} 630 -2210 0 0 {name=l5}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 510 -5000 0 0 {name=x1 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 600 -5000 0 0 {name=x2 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 690 -5000 0 0 {name=x3 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 780 -5000 0 0 {name=x4 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 870 -5000 0 0 {name=x7 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 960 -5000 0 0 {name=x9 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1050 -5000 0 0 {name=x10 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1140 -5000 0 0 {name=x11 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1230 -5000 0 0 {name=x12 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1320 -5000 0 0 {name=x13 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1410 -5000 0 0 {name=x14 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1500 -5000 0 0 {name=x15 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 510 -4890 0 0 {name=x16 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 600 -4890 0 0 {name=x17 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 690 -4890 0 0 {name=x18 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 780 -4890 0 0 {name=x19 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 870 -4890 0 0 {name=x20 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 960 -4890 0 0 {name=x21 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1050 -4890 0 0 {name=x22 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1140 -4890 0 0 {name=x23 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1230 -4890 0 0 {name=x24 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1320 -4890 0 0 {name=x25 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1410 -4890 0 0 {name=x26 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1500 -4890 0 0 {name=x27 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1490 -4820 2 0 {name=x28 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1400 -4820 2 0 {name=x29 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1310 -4820 2 0 {name=x30 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1220 -4820 2 0 {name=x31 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1130 -4820 2 0 {name=x32 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1040 -4820 2 0 {name=x33 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 950 -4820 2 0 {name=x34 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 860 -4820 2 0 {name=x35 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 770 -4820 2 0 {name=x36 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 680 -4820 2 0 {name=x37 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 590 -4820 2 0 {name=x38 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 500 -4820 2 0 {name=x39 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 510 -4710 0 0 {name=x40 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 600 -4710 0 0 {name=x41 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 690 -4710 0 0 {name=x42 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 780 -4710 0 0 {name=x43 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 870 -4710 0 0 {name=x44 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 960 -4710 0 0 {name=x45 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1050 -4710 0 0 {name=x46 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1140 -4710 0 0 {name=x47 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1230 -4710 0 0 {name=x48 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1320 -4710 0 0 {name=x49 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1410 -4710 0 0 {name=x50 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1500 -4710 0 0 {name=x51 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1490 -4640 2 0 {name=x52 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1400 -4640 2 0 {name=x53 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1310 -4640 2 0 {name=x54 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1220 -4640 2 0 {name=x55 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1130 -4640 2 0 {name=x56 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1040 -4640 2 0 {name=x57 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 950 -4640 2 0 {name=x58 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 860 -4640 2 0 {name=x59 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 770 -4640 2 0 {name=x60 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 680 -4640 2 0 {name=x61 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 590 -4640 2 0 {name=x62 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 500 -4640 2 0 {name=x63 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 500 -4560 0 0 {name=x64 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 590 -4560 0 0 {name=x65 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 680 -4560 0 0 {name=x66 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 770 -4560 0 0 {name=x67 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 860 -4560 0 0 {name=x68 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 950 -4560 0 0 {name=x69 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1040 -4560 0 0 {name=x70 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1130 -4560 0 0 {name=x71 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1220 -4560 0 0 {name=x72 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1310 -4560 0 0 {name=x73 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1400 -4560 0 0 {name=x74 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1490 -4560 0 0 {name=x75 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 460 -5000 0 0 {name=p4 sig_type=std_logic lab=12_in
}
C {lab_pin.sym} 1550 -5000 2 0 {name=p6 sig_type=std_logic lab=12_out
}
C {lab_pin.sym} 460 -4890 0 0 {name=p7 sig_type=std_logic lab=24_in
}
C {lab_pin.sym} 440 -4820 0 0 {name=p8 sig_type=std_logic lab=24_out
}
C {lab_pin.sym} 460 -4710 0 0 {name=p9 sig_type=std_logic lab=36_in
}
C {lab_pin.sym} 1540 -4560 2 0 {name=p10 sig_type=std_logic lab=36_out
}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1930 -5040 0 0 {name=x76 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2020 -5040 0 0 {name=x77 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2110 -5040 0 0 {name=x78 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2200 -5040 0 0 {name=x79 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2290 -5040 0 0 {name=x80 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2380 -5040 0 0 {name=x81 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2470 -5040 0 0 {name=x82 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2560 -5040 0 0 {name=x83 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2650 -5040 0 0 {name=x84 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2740 -5040 0 0 {name=x85 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2830 -5040 0 0 {name=x86 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2920 -5040 0 0 {name=x87 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2910 -4970 2 0 {name=x88 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2820 -4970 2 0 {name=x89 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2730 -4970 2 0 {name=x90 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2640 -4970 2 0 {name=x91 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2550 -4970 2 0 {name=x92 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2460 -4970 2 0 {name=x93 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2370 -4970 2 0 {name=x94 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2280 -4970 2 0 {name=x95 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2190 -4970 2 0 {name=x96 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2100 -4970 2 0 {name=x97 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2010 -4970 2 0 {name=x98 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1920 -4970 2 0 {name=x99 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 1880 -5040 0 0 {name=p11 sig_type=std_logic lab=48_in
}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1930 -4890 0 0 {name=x100 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2020 -4890 0 0 {name=x101 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2110 -4890 0 0 {name=x102 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2200 -4890 0 0 {name=x103 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2290 -4890 0 0 {name=x104 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2380 -4890 0 0 {name=x105 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2470 -4890 0 0 {name=x106 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2560 -4890 0 0 {name=x107 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2650 -4890 0 0 {name=x108 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2740 -4890 0 0 {name=x109 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2830 -4890 0 0 {name=x110 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2920 -4890 0 0 {name=x111 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2910 -4820 2 0 {name=x112 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2820 -4820 2 0 {name=x113 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2730 -4820 2 0 {name=x114 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2640 -4820 2 0 {name=x115 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2550 -4820 2 0 {name=x116 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2460 -4820 2 0 {name=x117 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2370 -4820 2 0 {name=x118 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2280 -4820 2 0 {name=x119 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2190 -4820 2 0 {name=x120 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2100 -4820 2 0 {name=x121 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2010 -4820 2 0 {name=x122 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1920 -4820 2 0 {name=x123 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 1860 -4820 0 0 {name=p12 sig_type=std_logic lab=48_out}
C {lab_pin.sym} 650 -2180 2 0 {name=p13 sig_type=std_logic lab=12_in
}
C {lab_pin.sym} 1150 -2200 0 0 {name=p14 sig_type=std_logic lab=12_out
}
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 520 -1890 0 0 {name=x124 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_xor2_1.sym} 1210 -2010 0 0 {name=x125 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 1400 -2010 0 0 {name=x126 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 370 -1910 0 0 {name=p15 sig_type=std_logic lab=clk_in
}
C {lab_pin.sym} 1270 -2030 0 0 {name=p16 sig_type=std_logic lab=clk_in
}
C {iopin.sym} 1530 -2030 0 0 {name=p17 lab=vout1

}
C {noconn.sym} 1510 -2010 2 0 {name=l7}
C {lab_wire.sym} 1310 -1960 0 0 {name=p18 sig_type=std_logic lab=tiehi
}
C {lab_wire.sym} 420 -1870 0 0 {name=p21 sig_type=std_logic lab=tiehi
}
C {noconn.sym} 610 -1920 0 0 {name=l8}
C {lab_pin.sym} 630 -1890 2 0 {name=p22 sig_type=std_logic lab=24_in
}
C {lab_pin.sym} 1130 -1910 0 0 {name=p23 sig_type=std_logic lab=24_out
}
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 500 -1580 0 0 {name=x127 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_xor2_1.sym} 1190 -1700 0 0 {name=x128 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 1380 -1700 0 0 {name=x129 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 350 -1600 0 0 {name=p24 sig_type=std_logic lab=clk_in
}
C {lab_pin.sym} 1250 -1720 0 0 {name=p25 sig_type=std_logic lab=clk_in
}
C {iopin.sym} 1510 -1720 0 0 {name=p26 lab=vout2
}
C {noconn.sym} 1490 -1700 2 0 {name=l9}
C {lab_wire.sym} 1290 -1650 0 0 {name=p28 sig_type=std_logic lab=tiehi
}
C {lab_wire.sym} 400 -1560 0 0 {name=p29 sig_type=std_logic lab=tiehi
}
C {noconn.sym} 590 -1610 0 0 {name=l10}
C {lab_pin.sym} 610 -1580 2 0 {name=p30 sig_type=std_logic lab=36_in
}
C {lab_pin.sym} 1110 -1600 0 0 {name=p31 sig_type=std_logic lab=36_out
}
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 490 -1320 0 0 {name=x130 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_xor2_1.sym} 1180 -1440 0 0 {name=x131 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 1370 -1440 0 0 {name=x132 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 340 -1340 0 0 {name=p32 sig_type=std_logic lab=clk_in
}
C {lab_pin.sym} 1240 -1460 0 0 {name=p33 sig_type=std_logic lab=clk_in
}
C {iopin.sym} 1500 -1460 0 0 {name=p34 lab=vout3
}
C {noconn.sym} 1480 -1440 2 0 {name=l12}
C {lab_wire.sym} 1280 -1390 0 0 {name=p35 sig_type=std_logic lab=tiehi
}
C {lab_wire.sym} 390 -1300 0 0 {name=p36 sig_type=std_logic lab=tiehi
}
C {noconn.sym} 580 -1350 0 0 {name=l13}
C {lab_pin.sym} 600 -1320 2 0 {name=p37 sig_type=std_logic lab=48_in
}
C {lab_pin.sym} 1100 -1340 0 0 {name=p38 sig_type=std_logic lab=48_out
}
C {iopin.sym} 1530 -2320 0 0 {name=p3 lab=vout

}
C {lab_wire.sym} 1310 -2300 0 0 {name=p39 sig_type=std_logic lab=xor_out}
C {lab_wire.sym} 1290 -2010 0 0 {name=p40 sig_type=std_logic lab=xor_out1}
C {lab_wire.sym} 1280 -1700 0 0 {name=p41 sig_type=std_logic lab=xor_out2}
C {lab_wire.sym} 1280 -1440 0 0 {name=p42 sig_type=std_logic lab=xor_out3}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1910 -4640 0 0 {name=x133 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2000 -4640 0 0 {name=x134 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2090 -4640 0 0 {name=x135 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2180 -4640 0 0 {name=x136 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2270 -4640 0 0 {name=x137 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2360 -4640 0 0 {name=x138 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2450 -4640 0 0 {name=x139 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2540 -4640 0 0 {name=x140 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2630 -4640 0 0 {name=x141 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2720 -4640 0 0 {name=x142 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2810 -4640 0 0 {name=x143 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2900 -4640 0 0 {name=x144 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2890 -4570 2 0 {name=x145 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2800 -4570 2 0 {name=x146 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2710 -4570 2 0 {name=x147 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2620 -4570 2 0 {name=x148 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2530 -4570 2 0 {name=x149 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2440 -4570 2 0 {name=x150 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2350 -4570 2 0 {name=x151 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2260 -4570 2 0 {name=x152 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2170 -4570 2 0 {name=x153 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2080 -4570 2 0 {name=x154 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1990 -4570 2 0 {name=x155 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1900 -4570 2 0 {name=x156 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 1860 -4640 0 0 {name=p44 sig_type=std_logic lab=96_in
}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1910 -4490 0 0 {name=x157 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2000 -4490 0 0 {name=x158 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2090 -4490 0 0 {name=x159 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2180 -4490 0 0 {name=x160 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2270 -4490 0 0 {name=x161 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2360 -4490 0 0 {name=x162 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2450 -4490 0 0 {name=x163 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2540 -4490 0 0 {name=x164 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2630 -4490 0 0 {name=x165 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2720 -4490 0 0 {name=x166 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2810 -4490 0 0 {name=x167 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2900 -4490 0 0 {name=x168 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2890 -4420 2 0 {name=x169 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2800 -4420 2 0 {name=x170 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2710 -4420 2 0 {name=x171 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2620 -4420 2 0 {name=x172 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2530 -4420 2 0 {name=x173 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2440 -4420 2 0 {name=x174 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2350 -4420 2 0 {name=x175 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2260 -4420 2 0 {name=x176 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2170 -4420 2 0 {name=x177 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2080 -4420 2 0 {name=x178 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1990 -4420 2 0 {name=x179 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1900 -4420 2 0 {name=x180 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1920 -4300 0 0 {name=x181 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2010 -4300 0 0 {name=x182 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2100 -4300 0 0 {name=x183 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2190 -4300 0 0 {name=x184 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2280 -4300 0 0 {name=x185 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2370 -4300 0 0 {name=x186 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2460 -4300 0 0 {name=x187 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2550 -4300 0 0 {name=x188 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2640 -4300 0 0 {name=x189 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2730 -4300 0 0 {name=x190 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2820 -4300 0 0 {name=x191 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2910 -4300 0 0 {name=x192 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2900 -4230 2 0 {name=x193 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2810 -4230 2 0 {name=x194 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2720 -4230 2 0 {name=x195 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2630 -4230 2 0 {name=x196 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2540 -4230 2 0 {name=x197 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2450 -4230 2 0 {name=x198 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2360 -4230 2 0 {name=x199 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2270 -4230 2 0 {name=x200 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2180 -4230 2 0 {name=x201 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2090 -4230 2 0 {name=x202 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2000 -4230 2 0 {name=x203 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1910 -4230 2 0 {name=x204 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1920 -4150 0 0 {name=x205 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2010 -4150 0 0 {name=x206 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2100 -4150 0 0 {name=x207 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2190 -4150 0 0 {name=x208 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2280 -4150 0 0 {name=x209 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2370 -4150 0 0 {name=x210 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2460 -4150 0 0 {name=x211 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2550 -4150 0 0 {name=x212 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2640 -4150 0 0 {name=x213 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2730 -4150 0 0 {name=x214 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2820 -4150 0 0 {name=x215 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2910 -4150 0 0 {name=x216 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2900 -4080 2 0 {name=x217 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2810 -4080 2 0 {name=x218 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2720 -4080 2 0 {name=x219 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2630 -4080 2 0 {name=x220 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2540 -4080 2 0 {name=x221 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2450 -4080 2 0 {name=x222 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2360 -4080 2 0 {name=x223 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2270 -4080 2 0 {name=x224 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2180 -4080 2 0 {name=x225 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2090 -4080 2 0 {name=x226 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2000 -4080 2 0 {name=x227 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1910 -4080 2 0 {name=x228 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 1850 -4080 0 0 {name=p46 sig_type=std_logic lab=96_out}
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 490 -1010 0 0 {name=x229 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_xor2_1.sym} 1180 -1130 0 0 {name=x230 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 1370 -1130 0 0 {name=x231 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 340 -1030 0 0 {name=p43 sig_type=std_logic lab=clk_in
}
C {lab_pin.sym} 1240 -1150 0 0 {name=p45 sig_type=std_logic lab=clk_in
}
C {iopin.sym} 1500 -1150 0 0 {name=p47 lab=vout4
}
C {noconn.sym} 1480 -1130 2 0 {name=l3}
C {lab_wire.sym} 1280 -1080 0 0 {name=p48 sig_type=std_logic lab=tiehi
}
C {lab_wire.sym} 390 -990 0 0 {name=p49 sig_type=std_logic lab=tiehi
}
C {noconn.sym} 580 -1040 0 0 {name=l11}
C {lab_pin.sym} 600 -1010 2 0 {name=p50 sig_type=std_logic lab=96_in
}
C {lab_pin.sym} 1100 -1030 0 0 {name=p51 sig_type=std_logic lab=96_out
}
C {lab_wire.sym} 1280 -1130 0 0 {name=p52 sig_type=std_logic lab=xor_out4}
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 490 -690 0 0 {name=x232 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_xor2_1.sym} 1180 -810 0 0 {name=x233 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 1370 -810 0 0 {name=x234 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 340 -710 0 0 {name=p53 sig_type=std_logic lab=clk_in
}
C {lab_pin.sym} 1240 -830 0 0 {name=p54 sig_type=std_logic lab=clk_in
}
C {iopin.sym} 1500 -830 0 0 {name=p55 lab=vout5
}
C {noconn.sym} 1480 -810 2 0 {name=l14}
C {lab_wire.sym} 1280 -760 0 0 {name=p56 sig_type=std_logic lab=tiehi
}
C {lab_wire.sym} 390 -670 0 0 {name=p57 sig_type=std_logic lab=tiehi
}
C {noconn.sym} 580 -720 0 0 {name=l15}
C {lab_pin.sym} 600 -690 2 0 {name=p58 sig_type=std_logic lab=144_in
}
C {lab_pin.sym} 1100 -710 0 0 {name=p59 sig_type=std_logic lab=144_out
}
C {lab_wire.sym} 1280 -810 0 0 {name=p60 sig_type=std_logic lab=xor_out5}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3380 -5070 0 0 {name=x235 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3470 -5070 0 0 {name=x236 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3560 -5070 0 0 {name=x237 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3650 -5070 0 0 {name=x238 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3740 -5070 0 0 {name=x239 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3830 -5070 0 0 {name=x240 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3920 -5070 0 0 {name=x241 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4010 -5070 0 0 {name=x242 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4100 -5070 0 0 {name=x243 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4190 -5070 0 0 {name=x244 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4280 -5070 0 0 {name=x245 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4370 -5070 0 0 {name=x246 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4360 -5000 2 0 {name=x247 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4270 -5000 2 0 {name=x248 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4180 -5000 2 0 {name=x249 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4090 -5000 2 0 {name=x250 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4000 -5000 2 0 {name=x251 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3910 -5000 2 0 {name=x252 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3820 -5000 2 0 {name=x253 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3730 -5000 2 0 {name=x254 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3640 -5000 2 0 {name=x255 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3550 -5000 2 0 {name=x256 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3460 -5000 2 0 {name=x257 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3370 -5000 2 0 {name=x258 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 3330 -5070 0 0 {name=p61 sig_type=std_logic lab=192_in
}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3380 -4920 0 0 {name=x259 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3470 -4920 0 0 {name=x260 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3560 -4920 0 0 {name=x261 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3650 -4920 0 0 {name=x262 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3740 -4920 0 0 {name=x263 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3830 -4920 0 0 {name=x264 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3920 -4920 0 0 {name=x265 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4010 -4920 0 0 {name=x266 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4100 -4920 0 0 {name=x267 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4190 -4920 0 0 {name=x268 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4280 -4920 0 0 {name=x269 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4370 -4920 0 0 {name=x270 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4360 -4850 2 0 {name=x271 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4270 -4850 2 0 {name=x272 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4180 -4850 2 0 {name=x273 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4090 -4850 2 0 {name=x274 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4000 -4850 2 0 {name=x275 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3910 -4850 2 0 {name=x276 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3820 -4850 2 0 {name=x277 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3730 -4850 2 0 {name=x278 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3640 -4850 2 0 {name=x279 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3550 -4850 2 0 {name=x280 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3460 -4850 2 0 {name=x281 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3370 -4850 2 0 {name=x282 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3390 -4730 0 0 {name=x283 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3480 -4730 0 0 {name=x284 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3570 -4730 0 0 {name=x285 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3660 -4730 0 0 {name=x286 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3750 -4730 0 0 {name=x287 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3840 -4730 0 0 {name=x288 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3930 -4730 0 0 {name=x289 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4020 -4730 0 0 {name=x290 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4110 -4730 0 0 {name=x291 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4200 -4730 0 0 {name=x292 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4290 -4730 0 0 {name=x293 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4380 -4730 0 0 {name=x294 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4370 -4660 2 0 {name=x295 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4280 -4660 2 0 {name=x296 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4190 -4660 2 0 {name=x297 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4100 -4660 2 0 {name=x298 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4010 -4660 2 0 {name=x299 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3920 -4660 2 0 {name=x300 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3830 -4660 2 0 {name=x301 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3740 -4660 2 0 {name=x302 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3650 -4660 2 0 {name=x303 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3560 -4660 2 0 {name=x304 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3470 -4660 2 0 {name=x305 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3380 -4660 2 0 {name=x306 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3390 -4580 0 0 {name=x307 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3480 -4580 0 0 {name=x308 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3570 -4580 0 0 {name=x309 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3660 -4580 0 0 {name=x310 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3750 -4580 0 0 {name=x311 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3840 -4580 0 0 {name=x312 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3930 -4580 0 0 {name=x313 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4020 -4580 0 0 {name=x314 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4110 -4580 0 0 {name=x315 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4200 -4580 0 0 {name=x316 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4290 -4580 0 0 {name=x317 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4380 -4580 0 0 {name=x318 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4370 -4510 2 0 {name=x319 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4280 -4510 2 0 {name=x320 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4190 -4510 2 0 {name=x321 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4100 -4510 2 0 {name=x322 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4010 -4510 2 0 {name=x323 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3920 -4510 2 0 {name=x324 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3830 -4510 2 0 {name=x325 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3740 -4510 2 0 {name=x326 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3650 -4510 2 0 {name=x327 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3560 -4510 2 0 {name=x328 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3470 -4510 2 0 {name=x329 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3380 -4510 2 0 {name=x330 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3390 -4380 0 0 {name=x331 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3480 -4380 0 0 {name=x332 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3570 -4380 0 0 {name=x333 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3660 -4380 0 0 {name=x334 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3750 -4380 0 0 {name=x335 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3840 -4380 0 0 {name=x336 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3930 -4380 0 0 {name=x337 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4020 -4380 0 0 {name=x338 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4110 -4380 0 0 {name=x339 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4200 -4380 0 0 {name=x340 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4290 -4380 0 0 {name=x341 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4380 -4380 0 0 {name=x342 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4370 -4310 2 0 {name=x343 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4280 -4310 2 0 {name=x344 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4190 -4310 2 0 {name=x345 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4100 -4310 2 0 {name=x346 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4010 -4310 2 0 {name=x347 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3920 -4310 2 0 {name=x348 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3830 -4310 2 0 {name=x349 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3740 -4310 2 0 {name=x350 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3650 -4310 2 0 {name=x351 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3560 -4310 2 0 {name=x352 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3470 -4310 2 0 {name=x353 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3380 -4310 2 0 {name=x354 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3390 -4230 0 0 {name=x355 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3480 -4230 0 0 {name=x356 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3570 -4230 0 0 {name=x357 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3660 -4230 0 0 {name=x358 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3750 -4230 0 0 {name=x359 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3840 -4230 0 0 {name=x360 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3930 -4230 0 0 {name=x361 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4020 -4230 0 0 {name=x362 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4110 -4230 0 0 {name=x363 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4200 -4230 0 0 {name=x364 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4290 -4230 0 0 {name=x365 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4380 -4230 0 0 {name=x366 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4370 -4160 2 0 {name=x367 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4280 -4160 2 0 {name=x368 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4190 -4160 2 0 {name=x369 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4100 -4160 2 0 {name=x370 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4010 -4160 2 0 {name=x371 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3920 -4160 2 0 {name=x372 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3830 -4160 2 0 {name=x373 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3740 -4160 2 0 {name=x374 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3650 -4160 2 0 {name=x375 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3560 -4160 2 0 {name=x376 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3470 -4160 2 0 {name=x377 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3380 -4160 2 0 {name=x378 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3400 -4040 0 0 {name=x379 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3490 -4040 0 0 {name=x380 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3580 -4040 0 0 {name=x381 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3670 -4040 0 0 {name=x382 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3760 -4040 0 0 {name=x383 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3850 -4040 0 0 {name=x384 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3940 -4040 0 0 {name=x385 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4030 -4040 0 0 {name=x386 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4120 -4040 0 0 {name=x387 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4210 -4040 0 0 {name=x388 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4300 -4040 0 0 {name=x389 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4390 -4040 0 0 {name=x390 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4380 -3970 2 0 {name=x391 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4290 -3970 2 0 {name=x392 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4200 -3970 2 0 {name=x393 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4110 -3970 2 0 {name=x394 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4020 -3970 2 0 {name=x395 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3930 -3970 2 0 {name=x396 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3840 -3970 2 0 {name=x397 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3750 -3970 2 0 {name=x398 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3660 -3970 2 0 {name=x399 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3570 -3970 2 0 {name=x400 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3480 -3970 2 0 {name=x401 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3390 -3970 2 0 {name=x402 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3400 -3890 0 0 {name=x403 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3490 -3890 0 0 {name=x404 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3580 -3890 0 0 {name=x405 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3670 -3890 0 0 {name=x406 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3760 -3890 0 0 {name=x407 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3850 -3890 0 0 {name=x408 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3940 -3890 0 0 {name=x409 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4030 -3890 0 0 {name=x410 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4120 -3890 0 0 {name=x411 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4210 -3890 0 0 {name=x412 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4300 -3890 0 0 {name=x413 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4390 -3890 0 0 {name=x414 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4380 -3820 2 0 {name=x415 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4290 -3820 2 0 {name=x416 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4200 -3820 2 0 {name=x417 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4110 -3820 2 0 {name=x418 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 4020 -3820 2 0 {name=x419 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3930 -3820 2 0 {name=x420 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3840 -3820 2 0 {name=x421 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3750 -3820 2 0 {name=x422 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3660 -3820 2 0 {name=x423 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3570 -3820 2 0 {name=x424 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3480 -3820 2 0 {name=x425 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 3390 -3820 2 0 {name=x426 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 3330 -3820 0 0 {name=p64 sig_type=std_logic lab=192_out}
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 500 -410 0 0 {name=x427 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_xor2_1.sym} 1190 -530 0 0 {name=x428 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 1380 -530 0 0 {name=x429 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 350 -430 0 0 {name=p62 sig_type=std_logic lab=clk_in
}
C {lab_pin.sym} 1250 -550 0 0 {name=p63 sig_type=std_logic lab=clk_in
}
C {iopin.sym} 1510 -550 0 0 {name=p65 lab=vout6}
C {noconn.sym} 1490 -530 2 0 {name=l16}
C {lab_wire.sym} 1290 -480 0 0 {name=p66 sig_type=std_logic lab=tiehi
}
C {lab_wire.sym} 400 -390 0 0 {name=p67 sig_type=std_logic lab=tiehi
}
C {noconn.sym} 590 -440 0 0 {name=l17}
C {lab_pin.sym} 610 -410 2 0 {name=p68 sig_type=std_logic lab=192_in
}
C {lab_pin.sym} 1110 -430 0 0 {name=p69 sig_type=std_logic lab=192_out
}
C {lab_wire.sym} 1290 -530 0 0 {name=p70 sig_type=std_logic lab=xor_out6}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1910 -3920 0 0 {name=x430 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2000 -3920 0 0 {name=x431 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2090 -3920 0 0 {name=x432 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2180 -3920 0 0 {name=x433 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2270 -3920 0 0 {name=x434 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2360 -3920 0 0 {name=x435 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2450 -3920 0 0 {name=x436 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2540 -3920 0 0 {name=x437 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2630 -3920 0 0 {name=x438 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2720 -3920 0 0 {name=x439 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2810 -3920 0 0 {name=x440 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2900 -3920 0 0 {name=x441 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2890 -3850 2 0 {name=x442 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2800 -3850 2 0 {name=x443 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2710 -3850 2 0 {name=x444 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2620 -3850 2 0 {name=x445 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2530 -3850 2 0 {name=x446 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2440 -3850 2 0 {name=x447 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2350 -3850 2 0 {name=x448 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2260 -3850 2 0 {name=x449 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2170 -3850 2 0 {name=x450 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2080 -3850 2 0 {name=x451 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1990 -3850 2 0 {name=x452 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1900 -3850 2 0 {name=x453 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 1860 -3920 0 0 {name=p71 sig_type=std_logic lab=144_in
}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1910 -3770 0 0 {name=x454 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2000 -3770 0 0 {name=x455 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2090 -3770 0 0 {name=x456 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2180 -3770 0 0 {name=x457 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2270 -3770 0 0 {name=x458 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2360 -3770 0 0 {name=x459 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2450 -3770 0 0 {name=x460 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2540 -3770 0 0 {name=x461 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2630 -3770 0 0 {name=x462 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2720 -3770 0 0 {name=x463 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2810 -3770 0 0 {name=x464 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2900 -3770 0 0 {name=x465 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2890 -3700 2 0 {name=x466 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2800 -3700 2 0 {name=x467 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2710 -3700 2 0 {name=x468 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2620 -3700 2 0 {name=x469 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2530 -3700 2 0 {name=x470 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2440 -3700 2 0 {name=x471 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2350 -3700 2 0 {name=x472 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2260 -3700 2 0 {name=x473 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2170 -3700 2 0 {name=x474 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2080 -3700 2 0 {name=x475 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1990 -3700 2 0 {name=x476 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1900 -3700 2 0 {name=x477 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1920 -3580 0 0 {name=x478 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2010 -3580 0 0 {name=x479 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2100 -3580 0 0 {name=x480 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2190 -3580 0 0 {name=x481 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2280 -3580 0 0 {name=x482 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2370 -3580 0 0 {name=x483 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2460 -3580 0 0 {name=x484 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2550 -3580 0 0 {name=x485 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2640 -3580 0 0 {name=x486 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2730 -3580 0 0 {name=x487 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2820 -3580 0 0 {name=x488 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2910 -3580 0 0 {name=x489 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2900 -3510 2 0 {name=x490 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2810 -3510 2 0 {name=x491 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2720 -3510 2 0 {name=x492 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2630 -3510 2 0 {name=x493 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2540 -3510 2 0 {name=x494 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2450 -3510 2 0 {name=x495 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2360 -3510 2 0 {name=x496 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2270 -3510 2 0 {name=x497 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2180 -3510 2 0 {name=x498 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2090 -3510 2 0 {name=x499 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2000 -3510 2 0 {name=x500 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1910 -3510 2 0 {name=x501 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1920 -3430 0 0 {name=x502 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2010 -3430 0 0 {name=x503 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2100 -3430 0 0 {name=x504 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2190 -3430 0 0 {name=x505 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2280 -3430 0 0 {name=x506 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2370 -3430 0 0 {name=x507 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2460 -3430 0 0 {name=x508 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2550 -3430 0 0 {name=x509 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2640 -3430 0 0 {name=x510 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2730 -3430 0 0 {name=x511 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2820 -3430 0 0 {name=x512 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2910 -3430 0 0 {name=x513 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2900 -3360 2 0 {name=x514 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2810 -3360 2 0 {name=x515 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2720 -3360 2 0 {name=x516 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2630 -3360 2 0 {name=x517 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2540 -3360 2 0 {name=x518 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2450 -3360 2 0 {name=x519 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2360 -3360 2 0 {name=x520 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2270 -3360 2 0 {name=x521 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2180 -3360 2 0 {name=x522 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2090 -3360 2 0 {name=x523 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2000 -3360 2 0 {name=x524 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1910 -3360 2 0 {name=x525 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1920 -3250 0 0 {name=x526 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2010 -3250 0 0 {name=x527 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2100 -3250 0 0 {name=x528 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2190 -3250 0 0 {name=x529 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2280 -3250 0 0 {name=x530 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2370 -3250 0 0 {name=x531 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2460 -3250 0 0 {name=x532 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2550 -3250 0 0 {name=x533 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2640 -3250 0 0 {name=x534 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2730 -3250 0 0 {name=x535 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2820 -3250 0 0 {name=x536 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2910 -3250 0 0 {name=x537 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2900 -3180 2 0 {name=x538 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2810 -3180 2 0 {name=x539 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2720 -3180 2 0 {name=x540 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2630 -3180 2 0 {name=x541 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2540 -3180 2 0 {name=x542 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2450 -3180 2 0 {name=x543 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2360 -3180 2 0 {name=x544 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2270 -3180 2 0 {name=x545 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2180 -3180 2 0 {name=x546 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2090 -3180 2 0 {name=x547 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2000 -3180 2 0 {name=x548 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1910 -3180 2 0 {name=x549 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1920 -3100 0 0 {name=x550 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2010 -3100 0 0 {name=x551 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2100 -3100 0 0 {name=x552 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2190 -3100 0 0 {name=x553 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2280 -3100 0 0 {name=x554 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2370 -3100 0 0 {name=x555 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2460 -3100 0 0 {name=x556 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2550 -3100 0 0 {name=x557 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2640 -3100 0 0 {name=x558 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2730 -3100 0 0 {name=x559 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2820 -3100 0 0 {name=x560 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2910 -3100 0 0 {name=x561 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2900 -3030 2 0 {name=x562 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2810 -3030 2 0 {name=x563 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2720 -3030 2 0 {name=x564 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2630 -3030 2 0 {name=x565 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2540 -3030 2 0 {name=x566 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2450 -3030 2 0 {name=x567 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2360 -3030 2 0 {name=x568 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2270 -3030 2 0 {name=x569 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2180 -3030 2 0 {name=x570 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2090 -3030 2 0 {name=x571 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 2000 -3030 2 0 {name=x572 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1910 -3030 2 0 {name=x573 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 1850 -3030 0 0 {name=p74 sig_type=std_logic lab=144_out}
